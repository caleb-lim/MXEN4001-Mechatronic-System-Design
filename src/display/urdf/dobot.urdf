Commit message: M10 URDF

File: src/display/urdf/dobot.urdf (robot description, URDF)
Before this commit: robot magician, 6 links, 5 joints
Joints:
- joint joint_2: origin xyz=0 0 0 rpy=-1.570796325 -1.570796325 0 -> xyz=0 0 0.0528 rpy=-1.570796325 -1.570796325 0
